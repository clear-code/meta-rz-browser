# Copyright (C) 2026 ClearCode Inc.
# SPDX-License-Identifier: MIT

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://hid-multitouch.cfg "
